DESCRIPTION = "Library to easily read single chars and key strokes"
HOMEPAGE = "https://github.com/magmax/python-readchar"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENCE;md5=d44366d0837f2452f853010b4be5fba8"

SRC_URI[sha256sum] = "91ce3faf07688de14d800592951e5575e9c7a3213738ed01d394dcc949b79adb"

inherit pypi python_poetry_core
