DESCRIPTION = "Easy, practical library for making terminal apps"
HOMEPAGE = "https://github.com/jquast/blessed"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=36ef5c12dbdce2335af53125dfd0515d"

SRC_URI[sha256sum] = "ece8bbc4758ab9176452f4e3a719d70088eb5739798cd5582c9e05f2a28337ec"

inherit pypi python_poetry_core
