DESCRIPTION = "Collection of common interactive command line user interfaces, based on Inquirer.js"
HOMEPAGE = "https://github.com/magmax/python-inquirer"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a0faf901869ad19fe1c5a7328303887d"

SRC_URI[sha256sum] = "8edc99c076386ee2d2204e5e3653c2488244e82cb197b2d498b3c1b5ffb25d0b"

inherit pypi python_poetry_core
